Commit message: Fix some minor bugs and inconsistencies

File: src/templates/resource/urdf/robot.urdf (robot description, URDF)
Before this commit: robot bb_head, 1 links, 0 joints
Links:
- link base_link: geometry visual cylinder length=0.1 radius=0.1
